# Repository mkronmiller/Dactyl-Manuform-PCB-Plate

## KiCad design Dactyl Full/flex/flex.kicad_pcb

Board: 2 copper layers, 126.5 x 148.9 mm, 79 parts (58 on the bottom side), 45 nets.

Parts:
D1, D2, D3, D4, D5, D6, D7, D8, D9, D10, D11, D12, D13, D14, D15, D16, D17, D18, D19, D20, D21, D22, D23, D24, D25, D26, D27, D28, D29, D30, D31, D32: D; Diode_TH_SOD123
J1, J14: Conn_01x06_Female; PinSocket_1x06_P2.54mm_Vertical
J2: Conn_01x07_Female; PinSocket_1x07_P2.54mm_Vertical
J3, J4, J5, J6, J7, J8, J9, J10, J11, J12, J13, J15: Conn_01x02_Female; SolderWire-0.15sqmm_1x01_D0.5mm_OD1.5mm
SW1, SW2, SW3, SW4, SW5, SW6, SW7, SW8, SW9, SW10, SW11, SW12, SW13, SW14, SW15, SW16, SW17, SW18, SW19, SW20, SW21, SW22, SW23, SW24, SW25, SW26, SW27, SW28, SW29, SW30, SW31, SW32: SW_Push; SW_MX_reversible

Connections:
unnamed: D1.2 (A), SW1.2
unnamed: D2.2 (A), SW2.2
unnamed: D3.2 (A), SW3.2
unnamed: D4.2 (A), SW4.2
unnamed: D5.2 (A), SW5.2
unnamed: D6.2 (A), SW6.2
unnamed: D7.2 (A), SW7.2
unnamed: D8.2 (A), SW8.2
unnamed: D9.2 (A), SW9.2
unnamed: D10.2 (A), SW10.2
unnamed: D11.2 (A), SW11.2
unnamed: D12.2 (A), SW12.2
unnamed: D13.2 (A), SW13.2
unnamed: D14.2 (A), SW14.2
unnamed: D15.2 (A), SW15.2
unnamed: D16.2 (A), SW16.2
unnamed: D17.2 (A), SW17.2
unnamed: D18.2 (A), SW18.2
unnamed: D19.2 (A), SW19.2
unnamed: D20.2 (A), SW20.2
unnamed: D21.2 (A), SW21.2
unnamed: D22.2 (A), SW22.2
unnamed: D23.2 (A), SW23.2
unnamed: D24.2 (A), SW24.2
unnamed: D25.2 (A), SW25.2
unnamed: D26.2 (A), SW26.2
unnamed: D27.2 (A), SW27.2
unnamed: D28.2 (A), SW28.2
unnamed: D29.2 (A), SW29.2
unnamed: D30.2 (A), SW30.2
unnamed: D31.2 (A), SW31.2
unnamed: D32.2 (A), SW32.2
col1: D1.1 (K), D2.1 (K), D3.1 (K), D4.1 (K), D27.1 (K), J9.1, J14.1
col2: D5.1 (K), D6.1 (K), D7.1 (K), D8.1 (K), D28.1 (K), J1.2, J10.1, J14.2
col3: D9.1 (K), D10.1 (K), D11.1 (K), D12.1 (K), D13.1 (K), D29.1 (K), J1.3, J11.1, J14.3
col4: D14.1 (K), D15.1 (K), D16.1 (K), D17.1 (K), D18.1 (K), D30.1 (K), J1.4, J12.1, J14.4
col5: D19.1 (K), D20.1 (K), D21.1 (K), D22.1 (K), D31.1 (K), J1.5, J13.1, J14.5
col6: D23.1 (K), D24.1 (K), D25.1 (K), D26.1 (K), D32.1 (K), J1.6, J14.6, J15.1
row0: J2.1, J3.1, SW27.1, SW28.1, SW29.1, SW30.1, SW31.1, SW32.1
row1: J2.2, J4.1, SW1.1, SW5.1, SW9.1, SW14.1, SW19.1, SW23.1
row2: J2.3, J5.1, SW2.1, SW6.1, SW10.1, SW15.1, SW20.1, SW24.1
row3: J2.4, J6.1, SW3.1, SW7.1, SW11.1, SW16.1, SW21.1, SW25.1
row4: J2.5, J7.1, SW4.1, SW8.1, SW12.1, SW17.1, SW22.1, SW26.1
row5: J2.6, J8.1, SW13.1, SW18.1
row6: J1.1, J2.7

## Commit log

2022-03-22 Added Extended Keys

Notices in the files:
Dactyl Full/flex/flex.kicad_pcb:
Licensed under CC BY-NC-SA 4.0
Copyright Quentin Lebastard 2021
